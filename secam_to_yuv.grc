options:
  parameters:
    author: itewreed, tony9954
    description: Takes luma and secam chroma TBC files and generates YUV file
    generate_options: qt_gui
    id: secam2yuv
    output_language: python
    title: secam TBC files to YUV file
  states: {}

blocks:
- name: chroma_range_blue
  id: variable_qtgui_range
  parameters:
    label: '"Color Blue"'
    start: '10'
    step: '0.05'
    stop: '14'
    value: '12.45'
  states: {}
- name: chroma_range_red
  id: variable_qtgui_range
  parameters:
    label: '"Color Red"'
    start: '10'
    step: '0.05'
    stop: '14'
    value: '12.90'
  states: {}
- name: colordelay
  id: variable
  parameters:
    comment: |-
      885 with band pass enabled
      1100 without band pass enabled
    value: 1070+sample_shift
  states: {}
- name: fm_demph
  id: variable
  parameters:
    value: '150e-8'
  states: {}
- name: invert_crcb_switch
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: line_length
  id: variable
  parameters:
    comment: |-
      910 NTSC
      1135 PAL
    value: line_length2+sample_shift
  states: {}
- name: line_length2
  id: variable
  parameters:
    comment: |-
      910 NTSC
      1135 PAL
    value: '1135'
  states: {}
- name: lines_per_frame
  id: variable
  parameters:
    comment: |-
      525 NTSC
      625 PAL
    value: '625'
  states: {}
- name: lines_per_frame_discard
  id: variable
  parameters:
    comment: |-
      Typically 1
      To discard last line
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      line_length / 64µs

      (formula does not hold true for ntsc)
    value: 1135/(64e-6)
  states: {}
- name: sample_shift
  id: variable
  parameters:
    value: '50'
  states: {}
- name: startfield
  id: variable
  parameters:
    value: '0'
  states: {}
- name: startfield_old
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_0_1_0
  id: analog_const_source_x
  parameters:
    const: '32768'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: chroma_range_red
    type: float
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: chroma_range_blue
    type: float
  states: {}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_2_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_2_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_2_2
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_3
  id: analog_const_source_x
  parameters:
    const: '-1'
    type: float
  states: {}
- name: analog_const_source_x_3_0
  id: analog_const_source_x
  parameters:
    const: '-1'
    type: float
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: fm_demph
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: fm_demph
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      87500 where did i get this?

      1/4th of  350k
    gain: samp_rate/(2*math.pi*87500)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      87500 where did i get this?

      1/4th of  350k
    gain: samp_rate/(2*math.pi*87500)
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_0_0_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_0_0_0_0
  id: analog_rail_ff
  parameters:
    hi: '0'
    lo: '-2'
  states: {}
- name: analog_rail_ff_0_0_0_0_0
  id: analog_rail_ff
  parameters:
    hi: '0'
    lo: '-2'
  states: {state: disabled}
- name: analog_rail_ff_0_0_0_1
  id: analog_rail_ff
  parameters:
    hi: '2'
    lo: '0'
  states: {}
- name: analog_rail_ff_0_0_0_1_0
  id: analog_rail_ff
  parameters:
    hi: '2'
    lo: '0'
  states: {state: disabled}
- name: analog_rail_ff_0_0_1
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_0_0_2
  id: analog_rail_ff
  parameters:
    hi: '255'
    lo: '0'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '0'
    comment: "Db = U\nf0B = 4 250 000 ±2 000Hz [B-Y subcarrier rest frequency]\r\ndf0B = 230 ±7kHz [nominal deviation of B-Y subcarrier]"
    decim: '1'
    gain: '1'
    high_cutoff_freq: 4250000+1000000
    low_cutoff_freq: 4250000-1000000
    samp_rate: round(samp_rate*1.0009)
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_KAISER
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    beta: '0'
    comment: "Dr = V\nf0R = 4 406 260 ±2 000Hz [B-Y subcarrier rest frequency]\r\ndf0R = 280 ±9kHz [nominal deviation of R-Y subcarrier]"
    decim: '1'
    gain: '1'
    high_cutoff_freq: 4406260+1000000
    low_cutoff_freq: 4406260-1000000
    samp_rate: round(samp_rate*1.0009)
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_KAISER
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_abs_xx_0_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '.6'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_0_1
  id: blocks_deinterleave
  parameters:
    type: float
  states: {}
- name: blocks_deinterleave_1_0
  id: blocks_deinterleave
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_deinterleave_1_0_0
  id: blocks_deinterleave
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: line_length+1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: colordelay
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: colordelay
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: outputdir + "/" + videofile + "_sf" + str(startfield) + ".bin"
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: inputdir + "/" + videofile + ".tbc"
    offset: (1135*626)*startfield
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    comment: |-
      Offset can be set to fix pink
      1135*626 is an offset of one frame
    file: inputdir + "/" + videofile + "_chroma.tbc"
    offset: (1135*626)*startfield
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0_0_0_1
  id: blocks_float_to_uchar
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_uchar_0_0_0_0_1_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_uchar_0_1
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '127'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '180'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '127'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '.25'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.25'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.75'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.75'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: line_length
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: line_length
  states: {state: disabled}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_null_sink_0_1_2
  id: blocks_null_sink
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_4
  id: blocks_null_sink
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_null_sink_4_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_null_sink_4_1
  id: blocks_null_sink
  parameters:
    type: float
    vlen: line_length
  states: {}
- name: blocks_repeat_0_0_2
  id: blocks_repeat
  parameters:
    interp: '2'
    type: float
    vlen: line_length
  states: {}
- name: blocks_repeat_0_0_2_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: float
    vlen: line_length
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: (invert_crcb+invert_crcb_switch)
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: line_length
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: (invert_crcb+invert_crcb_switch)
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_demux_0_1
  id: blocks_stream_demux
  parameters:
    lengths: (lines_per_frame, lines_per_frame_discard)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_demux_0_1_2
  id: blocks_stream_demux
  parameters:
    lengths: (lines_per_frame, lines_per_frame_discard)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_demux_1
  id: blocks_stream_demux
  parameters:
    lengths: (313, 312)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_demux_1_0
  id: blocks_stream_demux
  parameters:
    lengths: (313, 312)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_demux_1_0_0
  id: blocks_stream_demux
  parameters:
    lengths: (313, 312)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_demux_2
  id: blocks_stream_demux
  parameters:
    lengths: (312, 1)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_demux_2_0
  id: blocks_stream_demux
  parameters:
    lengths: (312, 1)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_demux_2_1
  id: blocks_stream_demux
  parameters:
    lengths: (312, 1)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (line_length2, sample_shift)
    type: float
  states: {}
- name: blocks_stream_mux_0_1
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_mux_0_1_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
    vlen: line_length
  states: {}
- name: blocks_stream_mux_0_2
  id: blocks_stream_mux
  parameters:
    lengths: (line_length2, sample_shift)
    type: float
  states: {}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: (line_length, 1)
    type: float
  states: {}
- name: blocks_stream_mux_1_0
  id: blocks_stream_mux
  parameters:
    lengths: (line_length, 1)
    type: float
  states: {}
- name: blocks_stream_mux_1_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (line_length, 1)
    type: float
  states: {}
- name: blocks_stream_mux_1_1
  id: blocks_stream_mux
  parameters:
    lengths: (line_length, 1)
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_1_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_1_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_0_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: (line_length)*624
    type: float
  states: {}
- name: blocks_stream_to_vector_0_2_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: (line_length)*624
    type: float
  states: {}
- name: blocks_stream_to_vector_0_2_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: (line_length)*624
    type: float
  states: {}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_2_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_2_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_2_1
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_stream_to_vector_2_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_streams_to_stream_0
  id: blocks_streams_to_stream
  parameters:
    num_streams: '3'
    type: float
    vlen: (line_length)*624
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_2_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: (line_length)*624
    type: float
  states: {}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_0_2_1
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_0_2_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_0_2_2
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_1_1
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_1_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_2_0
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_2_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_2_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_2_1
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: blocks_vector_to_stream_2_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: line_length
    type: float
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: inputdir
  id: parameter
  parameters:
    type: str
    value: input directory (with tbcs)
  states: {}
- name: invert_crcb
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: outputdir
  id: parameter
  parameters:
    type: str
    value: output directory
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Blue Channel"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Red Channel"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '10000'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: green
    color2: blue
    color3: red
    ctrlpanel: 'True'
    nconnections: '3'
    size: '10000'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '255'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: startfield
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {state: disabled}
- name: video_sdl_sink_0_0_0_0
  id: video_sdl_sink
  parameters:
    comment: |-
      Check full frame,
      all samples
    display_height: lines_per_frame
    display_width: line_length+1
    fps: '0'
    height: lines_per_frame
    num_channels: '3'
    type: byte
    width: line_length+1
  states: {}
- name: video_sdl_sink_0_0_0_0_1
  id: video_sdl_sink
  parameters:
    comment: |-
      Check full frame,
      all samples
    display_height: int(lines_per_frame-1)*3
    display_width: (line_length+1)
    fps: '0'
    height: int(lines_per_frame-1)*3
    type: byte
    width: (line_length+1)
  states: {state: disabled}
- name: videofile
  id: parameter
  parameters:
    type: str
    value: videofile without .tbc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: y
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Db
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Dr
  states: {}
- name: virtual_sink_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: c
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: y_video_sdl
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Db_video_sdl
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: Dr_video_sdl
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: y_time_plot
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Db_video_sdl
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Dr_video_sdl
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: y_video_sdl
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: y_time_plot
  states: {}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: y
  states: {}
- name: virtual_source_2_1_0
  id: virtual_source
  parameters:
    stream_id: c
  states: {}
- name: virtual_source_2_1_0_0
  id: virtual_source
  parameters:
    stream_id: Dr
  states: {}
- name: virtual_source_2_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: Db
  states: {}
- name: virtual_source_2_1_0_1
  id: virtual_source
  parameters:
    stream_id: c
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_2, '1']
- [analog_const_source_x_0_0, '0', blocks_sub_xx_2_0, '1']
- [analog_const_source_x_0_1, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_0_1_0, '0', blocks_divide_xx_0_0, '1']
- [analog_const_source_x_1, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_1_0, '0', blocks_sub_xx_0_0, '1']
- [analog_const_source_x_2, '0', blocks_stream_mux_1, '1']
- [analog_const_source_x_2_0, '0', blocks_stream_mux_1_0, '1']
- [analog_const_source_x_2_0_0, '0', blocks_stream_mux_1_0_0, '1']
- [analog_const_source_x_2_2, '0', blocks_stream_mux_1_1, '1']
- [analog_const_source_x_3, '0', blocks_stream_mux_0_0, '1']
- [analog_const_source_x_3_0, '0', blocks_stream_mux_0_2, '1']
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_2, '0']
- [analog_fm_deemph_0_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_1, '1']
- [analog_quadrature_demod_cf_0_0, '0', analog_fm_deemph_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [analog_rail_ff_0, '0', blocks_add_const_vxx_0_1_0, '0']
- [analog_rail_ff_0_0, '0', blocks_stream_mux_0_2, '0']
- [analog_rail_ff_0_0_0, '0', virtual_sink_0_0_0, '0']
- [analog_rail_ff_0_0_0_0, '0', blocks_abs_xx_0, '0']
- [analog_rail_ff_0_0_0_0_0, '0', blocks_abs_xx_0_1, '0']
- [analog_rail_ff_0_0_0_1, '0', blocks_abs_xx_0_0, '0']
- [analog_rail_ff_0_0_0_1_0, '0', blocks_abs_xx_0_0_0, '0']
- [analog_rail_ff_0_0_1, '0', virtual_sink_0_0_0_0_0, '0']
- [analog_rail_ff_0_0_2, '0', blocks_stream_to_vector_0, '0']
- [analog_rail_ff_0_0_2, '0', virtual_sink_1, '0']
- [band_pass_filter_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [band_pass_filter_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_abs_xx_0, '0', blocks_delay_0_1, '0']
- [blocks_abs_xx_0_0, '0', blocks_delay_0_0, '0']
- [blocks_abs_xx_0_0_0, '0', blocks_delay_0_1, '0']
- [blocks_abs_xx_0_1, '0', blocks_delay_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', analog_rail_ff_0_0_0_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', analog_rail_ff_0_0_0_0_0, '0']
- [blocks_add_const_vxx_0_1, '0', analog_rail_ff_0_0_0_1, '0']
- [blocks_add_const_vxx_0_1_0, '0', blocks_delay_0, '0']
- [blocks_add_const_vxx_0_1_1, '0', analog_rail_ff_0_0_0_1_0, '0']
- [blocks_add_xx_0, '0', blocks_sub_xx_2_0, '0']
- [blocks_add_xx_0_1, '0', blocks_sub_xx_2, '0']
- [blocks_deinterleave_0, '0', blocks_add_xx_0, '0']
- [blocks_deinterleave_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_deinterleave_0_1, '0', blocks_add_xx_0_1, '0']
- [blocks_deinterleave_0_1, '1', blocks_multiply_const_vxx_0_1, '0']
- [blocks_deinterleave_1_0, '0', blocks_selector_0, '1']
- [blocks_deinterleave_1_0, '1', blocks_selector_0, '0']
- [blocks_deinterleave_1_0, '1', blocks_selector_0, '2']
- [blocks_deinterleave_1_0_0, '0', blocks_selector_0_0, '0']
- [blocks_deinterleave_1_0_0, '0', blocks_selector_0_0, '2']
- [blocks_deinterleave_1_0_0, '1', blocks_selector_0_0, '1']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_delay_0_1, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_divide_xx_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_divide_xx_0_0, '0', analog_rail_ff_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_uchar_to_float_0_0_1, '0']
- [blocks_float_to_uchar_0_0, '0', video_sdl_sink_0_0_0_0, '1']
- [blocks_float_to_uchar_0_0_0, '0', video_sdl_sink_0_0_0_0, '0']
- [blocks_float_to_uchar_0_0_0_0_1, '0', blocks_file_sink_0, '0']
- [blocks_float_to_uchar_0_0_0_0_1_0, '0', video_sdl_sink_0_0_0_0_1, '0']
- [blocks_float_to_uchar_0_1, '0', video_sdl_sink_0_0_0_0, '2']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0_1, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_2, '0']
- [blocks_multiply_const_vxx_1_0, '0', analog_rail_ff_0_0_2, '0']
- [blocks_multiply_const_vxx_1_0, '0', virtual_sink_3, '0']
- [blocks_multiply_const_vxx_1_1, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_multiply_const_vxx_1_1, '0', virtual_sink_2_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_multiply_const_vxx_2_0_0, '0', blocks_stream_to_vector_0_0_1_0_0_0, '0']
- [blocks_multiply_const_vxx_2_0_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_2_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_2_0_0_0, '0', blocks_stream_to_vector_0_0_1_0_0_0_0, '0']
- [blocks_multiply_const_vxx_2_0_0_0, '0', qtgui_number_sink_1, '0']
- [blocks_repeat_0_0_2, '0', blocks_vector_to_stream_0_2_1_0, '0']
- [blocks_repeat_0_0_2_0, '0', blocks_vector_to_stream_0_2_1, '0']
- [blocks_selector_0, '0', blocks_repeat_0_0_2_0, '0']
- [blocks_selector_0_0, '0', blocks_repeat_0_0_2, '0']
- [blocks_stream_demux_0_1, '0', blocks_vector_to_stream_0_2, '0']
- [blocks_stream_demux_0_1, '1', blocks_null_sink_0_1, '0']
- [blocks_stream_demux_0_1_2, '0', blocks_vector_to_stream_0_2_2, '0']
- [blocks_stream_demux_0_1_2, '1', blocks_null_sink_0_1_2, '0']
- [blocks_stream_demux_1, '0', blocks_stream_demux_2, '0']
- [blocks_stream_demux_1, '1', blocks_vector_to_stream_2_0, '0']
- [blocks_stream_demux_1_0, '0', blocks_stream_demux_2_0, '0']
- [blocks_stream_demux_1_0, '1', blocks_vector_to_stream_2_0_0, '0']
- [blocks_stream_demux_1_0_0, '0', blocks_stream_demux_2_1, '0']
- [blocks_stream_demux_1_0_0, '1', blocks_vector_to_stream_2_0_0_0, '0']
- [blocks_stream_demux_2, '0', blocks_vector_to_stream_2, '0']
- [blocks_stream_demux_2, '1', blocks_null_sink_4, '0']
- [blocks_stream_demux_2_0, '0', blocks_vector_to_stream_2_1, '0']
- [blocks_stream_demux_2_0, '1', blocks_null_sink_4_0, '0']
- [blocks_stream_demux_2_1, '0', blocks_vector_to_stream_2_1_0, '0']
- [blocks_stream_demux_2_1, '1', blocks_null_sink_4_1, '0']
- [blocks_stream_mux_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_stream_mux_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_stream_mux_0_1, '0', blocks_vector_to_stream_1_1, '0']
- [blocks_stream_mux_0_1_0, '0', blocks_vector_to_stream_1_1_0, '0']
- [blocks_stream_mux_0_2, '0', blocks_stream_to_vector_0_1_0, '0']
- [blocks_stream_mux_1, '0', blocks_float_to_uchar_0_0_0, '0']
- [blocks_stream_mux_1_0, '0', blocks_float_to_uchar_0_0, '0']
- [blocks_stream_mux_1_0_0, '0', blocks_float_to_uchar_0_1, '0']
- [blocks_stream_mux_1_1, '0', blocks_float_to_uchar_0_0_0_0_1_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_stream_demux_1, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_stream_demux_1_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_stream_demux_1_0_0, '0']
- [blocks_stream_to_vector_0_0_1_0_0_0, '0', blocks_deinterleave_1_0, '0']
- [blocks_stream_to_vector_0_0_1_0_0_0_0, '0', blocks_deinterleave_1_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_stream_demux_0_1, '0']
- [blocks_stream_to_vector_0_1_0, '0', blocks_stream_demux_0_1_2, '0']
- [blocks_stream_to_vector_0_2_0, '0', blocks_streams_to_stream_0, '0']
- [blocks_stream_to_vector_0_2_0_1, '0', blocks_streams_to_stream_0, '1']
- [blocks_stream_to_vector_0_2_0_1_0, '0', blocks_streams_to_stream_0, '2']
- [blocks_stream_to_vector_2, '0', blocks_stream_mux_0, '0']
- [blocks_stream_to_vector_2_0, '0', blocks_stream_mux_0, '1']
- [blocks_stream_to_vector_2_0_0, '0', blocks_stream_mux_0_1, '1']
- [blocks_stream_to_vector_2_0_0_0, '0', blocks_stream_mux_0_1_0, '1']
- [blocks_stream_to_vector_2_1, '0', blocks_stream_mux_0_1, '0']
- [blocks_stream_to_vector_2_1_0, '0', blocks_stream_mux_0_1_0, '0']
- [blocks_streams_to_stream_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_2_0_0_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_multiply_const_vxx_2_0_0, '0']
- [blocks_sub_xx_2, '0', blocks_divide_xx_0_0, '0']
- [blocks_sub_xx_2_0, '0', blocks_divide_xx_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_deinterleave_0, '0']
- [blocks_uchar_to_float_0_0_1, '0', blocks_deinterleave_0_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_float_to_uchar_0_0_0_0_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_null_sink_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_mux_1_1, '0']
- [blocks_vector_to_stream_0_2, '0', virtual_sink_0, '0']
- [blocks_vector_to_stream_0_2_1, '0', analog_rail_ff_0_0_0, '0']
- [blocks_vector_to_stream_0_2_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0_2_1_0, '0', analog_rail_ff_0_0_1, '0']
- [blocks_vector_to_stream_0_2_1_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_vector_to_stream_0_2_2, '0', hilbert_fc_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_stream_to_vector_0_2_0, '0']
- [blocks_vector_to_stream_1_1, '0', blocks_stream_to_vector_0_2_0_1, '0']
- [blocks_vector_to_stream_1_1_0, '0', blocks_stream_to_vector_0_2_0_1_0, '0']
- [blocks_vector_to_stream_2, '0', blocks_stream_to_vector_2, '0']
- [blocks_vector_to_stream_2_0, '0', blocks_stream_to_vector_2_0, '0']
- [blocks_vector_to_stream_2_0_0, '0', blocks_stream_to_vector_2_0_0, '0']
- [blocks_vector_to_stream_2_0_0_0, '0', blocks_stream_to_vector_2_0_0_0, '0']
- [blocks_vector_to_stream_2_1, '0', blocks_stream_to_vector_2_1, '0']
- [blocks_vector_to_stream_2_1_0, '0', blocks_stream_to_vector_2_1_0, '0']
- [hilbert_fc_0, '0', virtual_sink_0_0_0_0_1, '0']
- [virtual_source_0, '0', blocks_stream_mux_1_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0, '1']
- [virtual_source_0_0, '0', blocks_stream_mux_1_0_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [virtual_source_1, '0', blocks_stream_mux_1, '0']
- [virtual_source_2, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_2_1, '0', analog_rail_ff_0, '0']
- [virtual_source_2_1_0, '0', band_pass_filter_0, '0']
- [virtual_source_2_1_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [virtual_source_2_1_0_0, '0', blocks_add_const_vxx_0_1_1, '0']
- [virtual_source_2_1_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [virtual_source_2_1_0_0_0, '0', blocks_add_const_vxx_0_1, '0']
- [virtual_source_2_1_0_1, '0', band_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
